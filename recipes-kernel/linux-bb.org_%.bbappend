SRC_URI += "file://conf/usb-gadget.cfg"
